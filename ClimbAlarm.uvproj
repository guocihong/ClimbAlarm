# Keil uVision project ClimbAlarm.uvproj, settings and files
target ClimbAlarm (MCS-51)
  device: STC12C5A32S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: ClimbAlarm +hex
  c flags: Optimize=8 SizeSpeed=1
  group system
    ./: STARTUP.A51 main.c system_init.c variable.c
  group task
    ./task/adc/: adc_task.c
    ./task/alarm/: alarm_task.c
    ./task/doorkeep/: doorkeep_task.c
    ./task/status/: status_task.c
    ./task/uart/: uart_task.c
  group driver
    ./driver/flash/: flash_drv.c
    ./driver/adc/: adc_drv.c
    ./driver/timer/: timer_drv.c
    ./driver/uart/: uart_drv.c
